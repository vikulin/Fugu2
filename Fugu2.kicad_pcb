# Repository vikulin/Fugu2

## KiCad design Fugu2.kicad_pcb

Board: 2 copper layers, 50.0 x 88.0 mm, 130 parts (57 on the bottom side), 57 nets.

Parts:
C1: 100nF, 25V; C_0805_2012Metric
C2, C4, C6, C7, C25: 100nF, X7R, 25V; C_0805_2012Metric
C3, C23, C30: 1uF, 10V, X7S; C_0805_2012Metric
C5: 2.2nF, 200V, X7S; C_1206_3216Metric
C8: 2.2nF, 200V, X7S; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9, C14, C16, C27: 1uF, 100V, X7S; C_0805_2012Metric
C10, C12: 470uF, 100V; CP_Radial_D18.0mm_P7.50mm
C11: 470uF, 100V; CP_Radial_D16.0mm_P7.50mm
C13: 4.7uF, 100V; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C15, C20, C24, C31: 10nF, 100V; C_0805_2012Metric
C17, C18: 220nF, 100V, X7S; C_0603_1608Metric
C19, C28: 10uF, 16V; C_0805_2012Metric
C21, C22: 10uF, 100V, X7S; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C33: 10n; C_0402_1005Metric
D1, D17: MSS1P4-M3/89A; D_MicroSMP_AK
D2: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D3, D4, D6: LESD5D5.0CT1G; D_SOD-523
D7, D8, D10, D11, D12: SS310; D_SOD-123
D9: ST40100C; TO-220-3_Horizontal_BottomHeatsink_NoHole
D13: SMAJ85A; D_SMA
D16: ST15100S; TO-277B_ThermalVias
D18: 62V; SOT-23-3
DZ1: SM2T3V3A; D_Powermite_KA
DZ2: BZT52C13-TP; D_SOD-123
F1, F3: 40A; Fuse_Blade_ATO_directSolderThin
F2: SMD1206B010TF/60 or 500mA fast, 50A; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad_TopOnly
H2, H3, H4, H5: MountingHole; MountingHole_3.2mm_M3_DIN965
J2: I2C Conn; PinSocket_1x04_P2.00mm_Vertical
J3: Conn_L_SW; SolderWire-1x01_D3.5mm
J4: MCU head; PinHeader_2x07_P2.54mm_Vertical_SMD_Pin1Left
J5: UART (CAN) Conn; PinSocket_1x04_P2.54mm_Vertical
J6: Conn_L_out; SolderWire-1x01_D3.5mm
J7: 3.3V PSU; PinHeader_1x03_P2.54mm_Vertical
J9, J10: 691256610002; TerminalBlock_WR-TBL_2566_1x02_P10.16mm
J11: QTGM027; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
L2: 10uH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
PWRGND1: TestPoint_THTPad_D1.5mm_Drill0.7mm
Q1, Q3: IPA050N10NM5S; TO-220-3_Horizontal_BottomHeatsink_SmallHole
Q2: IPP022N12NM6; TO-220-3_Horizontal_BottomHeatsink_NoHole
Q4, Q9: BSS123; SOT-23
Q5, Q6, Q7: TPH1R306PL,L1Q or NTMFS5C612NLT1G; Infineon_PG-TDSON-8_FL
Q8: GT800N10D3; VSON-8_3.3x3.3mm_P0.65mm_NexFET
R1: 20k; R_0805_2012Metric
R2, R3, R8, R9, R13, R14, R15, R16, R23, R45: 10k; R_0805_2012Metric
R4, R6, R10: 4.7, 1%; R_0805_2012Metric
R5, R7: 2.2, 1%; R_0805_2012Metric
R11, R12: 7.5; R_1206_3216Metric
R17, R18, R21, R43, R44: 200k; R_0805_2012Metric
R19, R25, R27: 22; R_0805_2012Metric
R20: 7.5k; R_0805_2012Metric
R22, R28, R29: 47k, 1%; R_0805_2012Metric
R24: 1M; R_0805_2012Metric
R26: 0.0005; R_2512_6332Metric_Pad2.72x3.40mm_HandSolder
R34: 1M; R_0402_1005Metric
R35, R36: 5.1k; R_0402_1005Metric
R37: 33k; R_0805_2012Metric
R38: 5.1k 1%; R_0402_1005Metric
SW1: SW_Push; SW_Push_SPST_NO_Alps_SKRK
TH1: NCP18XH103F03RB; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP1: RX; TestPoint_Pad_D1.5mm
TP2: TX; TestPoint_Pad_D1.5mm
TP3: GND; TestPoint_Pad_D1.5mm
TPA1: alert; TestPoint_Pad_D1.0mm
TPHO1: TestPoint_Pad_D1.5mm
TPINH1: INH; TestPoint_Pad_D1.0mm
TPINL1: INL; TestPoint_Pad_D1.0mm
TPLO1: TP_PWM_LO; TestPoint_Pad_D1.5mm
TPSD1: SD; TestPoint_Pad_D1.0mm
U1: UCC21330BQDRQ1; SOIC-16_3.9x9.9mm_P1.27mm
U2: ESP32-S3-WROOM-1-N4; ESP32-S3-WROOM-1-noPIN15
U3: INA226; VSSOP-10_3x3mm_P0.5mm
U5: AP3012; SOT-23-5
USB1: USBConn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
bfg1: TestPoint_Pad_D1.5mm
bfs1: TestPoint_Pad_D1.5mm

Connections:
+3.3V: C2.2, C4.2, C25.1, C30.1, D2.1 (VDD), DZ1.1 (K), J2.1, J4.5, J5.1, J7.3, L2.1, R2.1, R3.1, R13.2, R14.2, R15.2, R23.2, TH1.1, U1.3 (VCCI), U1.8 (VCCI), U2.2 (3V3), U2.7 (GPIO7/TOUCH7/ADC1_CH6), U3.6 (VS), U5.4 (~SHDN), U5.5 (IN)
+12V: C7.2, C28.1, D17.1 (K), R19.2, R37.1, U1.16 (VDDA)
/PowerSupply/SW: D17.2 (A), L2.2, U5.1 (SW)
ADC_Vin: C15.1, D6.1 (K), J4.9, R18.1, R20.2, U2.4 (GPIO4/TOUCH4/ADC1_CH3)
ALERT: J4.6, R15.1, TPA1.1 (1_1), U2.34 (MTDI/GPIO41/CLK_OUT1), U3.3 (~Alert)
BT+: F1.2, J9.1, R28.2
Bat+: D12.2 (A), F1.1, Q5.3 (D), Q6.3 (D), Q7.3 (D)
BflowG: C20.1, DZ2.1 (K), Q5.2 (G), Q6.2 (G), Q7.2 (G), R21.1, R22.2, R24.2, bfg1.1 (1_1)
BflowS: C10.1, C20.2, DZ2.2 (A), J6.1 (Pin_1_1), Q5.1 (S), Q6.1 (S), Q7.1 (S), R24.1, bfs1.1 (1_1)
BflowSD: J4.8, Q4.1 (G), R23.1, U2.33 (MTDO/GPIO40/CLK_OUT2)
BuckGND: C1.1, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C14.1, C16.2, C17.2, C18.2, C21.2, C22.2, C27.2, D9.1 (K), D9.3 (K), D16.A, J10.1, PWRGND1.1 (1_1), Q2.3 (S), R8.1, R17.1, R25.2, R26.1, U1.14 (VSSA)
CAN_RX: J5.3, U2.30 (SPIDQS/GPIO37/FSPIQ/SUBSPIQ)
CAN_TX: J5.4, U2.29 (SPIIO7/GPIO36/FSPICLK/SUBSPICLK)
EN: C3.2, R2.2, U2.3 (EN)
GND: C1.2, C2.1, C3.1, C4.1, C13.2, C15.2, C24.2, C25.2, C28.2, C30.2, C31.2, C33.2, D2.3 (VSS), D3.2 (A), D4.2 (A), D6.2 (A), D13.2 (A), D18.2 (A), DZ1.2 (A), J2.2, J4.2, J4.7, J5.2, J7.2, J9.2, J11.A12_B1 (GND2), J11.B12_A1 (GND1), Q4.2 (S), Q9.2 (S), R1.2, R16.1, R20.1, R26.2, R27.2, R29.1, R34.2, R35.2, R36.1, R38.2, R45.1, SW1.2, TP3.1 (1_1), U1.4 (GND), U2.1 (GND), U2.16 (GPIO46), U2.40 (GND), U2.41 (GND), U3.1 (A1), U3.2 (A0), U3.7 (GND), U5.2 (GND), USB1.1
HO: D1.1 (K), R4.1, R6.1, TPHO1.1 (1_1), U1.10 (OUTB)
INH: J4.10, TPINH1.1 (1_1), U1.2 (INB), U2.23 (GPIO21)
INL: J4.14, TPINL1.1 (1_1), U1.1 (INA), U2.22 (GPIO14/TOUCH14/ADC2_CH3/FSPIWP/FSPIDQS/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)
IO0: R3.2, SW1.1, U2.27 (GPIO0/BOOT)
LED: D2.4 (DIN), J4.1, U2.39 (GPIO1/TOUCH1/ADC1_CH0)
LO: R10.1, TPLO1.1 (1_1), U1.15 (OUTA)
LV_PGOOD: Q9.1 (G), R45.2, U2.28 (SPIIO6/GPIO35/FSPID/SUBSPID)
NTC: J4.13, R16.2, TH1.2, U2.12 (GPIO8/TOUCH8/ADC1_CH7/SUBSPICS1)
unnamed: C5.2, R12.1
unnamed: C8.1, R11.2
unnamed: C14.2, H1.1 (1_1), R17.2
unnamed: D1.2 (A), R5.2, R7.2
unnamed: D8.1 (K), R21.2
unnamed: D10.2 (A), R19.1
unnamed: C6.2, C19.1, D8.2 (A), D10.1 (K), U1.11 (VDDB)
unnamed: D11.2 (A), Q8.1 (S), R44.2
unnamed: D11.1 (K), D12.1 (K), F2.1
unnamed: C13.1, D7.1 (K), D13.1 (K), F2.2, J7.1
unnamed: C31.1, D18.1 (K), Q8.2 (G), Q9.3 (D), R43.2, R44.1
unnamed: J11.A5 (CC1), R35.1
unnamed: J11.B5 (CC2), R36.2
unnamed: C33.1, J11.SH (SHIELD), R34.1
unnamed: Q1.1 (G), R4.2, R7.1, R9.2
unnamed: Q2.1 (G), R8.2, R10.2
unnamed: Q3.1 (G), R5.1, R6.2
unnamed: Q4.3 (D), R22.1
unnamed: R1.1, U1.6 (DT)
unnamed: C24.1, R28.1, R29.2, U3.8 (Vbus)
unnamed: C23.1, R25.1, U3.10 (Vin+)
unnamed: C23.2, R27.1, U3.9 (Vin-)
unnamed: R37.2, R38.1, U5.3 (FB)
RX: TP1.1 (1_1), U2.36 (U0RXD/GPIO44/CLK_OUT2)
SCL: J2.4, J4.3, R14.1, U2.38 (GPIO2/TOUCH2/ADC1_CH1), U3.5 (SCL)
SD: J4.12, TPSD1.1 (1_1), U1.5 (DIS), U2.24 (GPIO47/SPICLK_P/SUBSPICLK_P_DIFF)
SDA: J2.3, J4.4, R13.1, U2.35 (MTMS/GPIO42), U3.4 (SDA)
SW: C6.1, C19.2, D9.2 (A), D16.K, J3.1 (Pin_1_1), Q1.3 (S), Q2.2 (D), Q3.3 (S), R9.1, R11.1, R12.2, U1.9 (VSSB)
Solar+: C5.1, C9.1, C11.1, C12.1, C16.1, C17.1, C18.1, C21.1, C22.1, C27.1, F3.2, Q1.2 (D), Q3.2 (D), Q8.3 (D), R18.2, R43.1
TX: TP2.1 (1_1), U2.37 (U0TXD/GPIO43/CLK_OUT1)
T_HV+: F3.1, J10.2
USB_D+: D4.1 (K), J11.A6 (D+), J11.B6 (D+), U2.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+), USB1.2
USB_D-: D3.1 (K), J11.A7 (D-), J11.B7 (D-), U2.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-), USB1.3
Vusb: D7.2 (A), J11.A4_B9 (VBUS1), J11.B4_A9 (VBUS2), USB1.4
